LINUX_VERSION ?= "5.4.77"
LINUX_RPI_BRANCH ?= "rpi-5.4.y"

SRCREV = "b8681a08ba16b15cc9f010bef2a24ffac0b054d1"

require linux-raspberrypi_5.4.inc

